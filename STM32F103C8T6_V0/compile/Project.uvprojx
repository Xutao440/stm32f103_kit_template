# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\mcu_kit\base;..\mcu_kit\bsp\bsp_dwt;..\mcu_kit\bsp\bsp_gpio;..\mcu_kit\bsp\bsp_pwm;..\mcu_kit\bsp\bsp_systick;..\mcu_kit\bsp\bsp_uart;..\mcu_kit\bsp;..\mcu_kit\fml_module\log;..\mcu_kit\SDK\Start;..\mcu_kit\SDK\Library;..\mcu_kit\SDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group mcu-kit/base
    ../mcu_kit/base/: base_check.h base_keyword.h base_limits.h base_type.h base_utils.h log.c log.h sys.c sys.h queue.c queue.h
  group mcu-kit/bsp
    ../mcu_kit/bsp/bsp_dwt/: bsp_dwt.c bsp_dwt.h
    ../mcu_kit/bsp/bsp_gpio/: bsp_gpio.c bsp_gpio.h
    ../mcu_kit/bsp/bsp_uart/: bsp_uart.c bsp_uart.h
    ../mcu_kit/bsp/: bsp_cfg.h
  group mcu-kit/SDK
    ../mcu_kit/SDK/Start/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
    ../mcu_kit/SDK/: stm32f10x_it.c
  group user_code
    ../user_code/: main.c
