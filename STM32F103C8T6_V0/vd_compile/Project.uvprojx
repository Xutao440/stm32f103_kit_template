# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\vd_mcu_kit\vd_base;..\vd_mcu_kit\vd_bsp\vd_bsp_dwt;..\vd_mcu_kit\vd_bsp\vd_bsp_gpio;..\vd_mcu_kit\vd_bsp\vd_bsp_pwm;..\vd_mcu_kit\vd_bsp\vd_bsp_systick;..\vd_mcu_kit\vd_bsp\vd_bsp_uart;..\vd_mcu_kit\vd_fml\fml_lib\log;..\vd_mcu_kit;..\vd_mcu_kit\vd_lib;..\vd_mcu_kit\vd_lib\Library;..\vd_mcu_kit\vd_lib\Start;..\vd_mcu_kit\vd_lib\vd_hal\vdchip_stm32f103xx_gpio;..\vd_mcu_kit\vd_bsp;..\vd_mcu_kit\vd_bsp\vd_bsp_timer;..\vd_mcu_kit\vd_bsp\vd_bsp_adc;..\vd_mcu_kit\vd_bsp\vd_bsp_soft_i2c;..\vd_mcu_kit\vd_bsp\vd_bsp_soft_spi;..\vd_mcu_kit\vd_fml\fml_module_peripheral\vd_fml_per_beep_module;..\vd_mcu_kit\vd_fml\fml_module_peripheral\vd_fml_per_led_module;..\vd_mcu_kit\vd_bsp\vd_bsp_soft_spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group mcu-kit/vd_base
    ../vd_mcu_kit/vd_base/: base_check.h base_keyword.h base_limits.h base_type.h base_utils.h
  group mcu-kit/vd_bsp
    ../vd_mcu_kit/vd_bsp/vd_bsp_dwt/: vd_bsp_dwt.c vd_bsp_dwt.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_gpio/: vd_bsp_gpio.c vd_bsp_gpio.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_pwm/: vd_bsp_pwm.c vd_bsp_pwm.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_systick/: vd_bsp_systick.c vd_bsp_systick.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_uart/: vd_bsp_uart.c vd_bsp_uart.h
    ../vd_mcu_kit/vd_bsp/: kit_driver_bsp_config.h vd_bsp_config.h vd_bsp_type.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_adc/: vd_bsp_adc.c vd_bsp_adc.h vd_bsp_adc_type.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_soft_i2c/: vd_bsp_soft_i2c.c vd_bsp_soft_i2c.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_soft_spi/: vd_bsp_soft_spi.c vd_bsp_soft_spi.h
    ../vd_mcu_kit/vd_bsp/vd_bsp_timer/: vd_bsp_timer.c vd_bsp_timer.h
  group mcu-kit/vd_fml/peripheral
    ../vd_mcu_kit/vd_fml/fml_module_peripheral/vd_fml_per_beep_module/: vd_fml_per_beep_module.c vd_fml_per_beep_module.h
    ../vd_mcu_kit/vd_fml/fml_module_peripheral/vd_fml_per_led_module/: vd_fml_per_led_module.c vd_fml_per_led_module.h
  group fml_limcu-kit/vd_fml/lib
    ../vd_mcu_kit/vd_fml/fml_lib/log/: log.c
  group mcu-kit/vd_lib/Library
    ../vd_mcu_kit/vd_lib/Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mcu-kit/vd_lib/Library/Start
    ../vd_mcu_kit/vd_lib/Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../vd_mcu_kit/vd_lib/: stm32f10x_it.c
  group mcu-kit/vd_lib/Library/vd_hal
    ../vd_mcu_kit/vd_lib/vd_hal/vdchip_stm32f103xx_gpio/: vdchip_stm32f103xx_gpio.c
  group mcu-lit/bord_config
    ../vd_mcu_kit/: board_config.h
  group vd_user_code
    ../vd_user_code/: main.c
